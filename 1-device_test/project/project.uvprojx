# Keil uVision project project.uvprojx, settings and files
target rt-thread (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: rt-thread +hex
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: __STDC_LIMIT_MACROS, STM32F103xE, __CLK_TCK=RT_TICK_PER_SECOND, __RTTHREAD__, USE_HAL_DRIVER, RT_USING_ARMLIBC, RT_USING_LIBC
  c include: libraries\HAL_Drivers\CMSIS\Include;rt-thread\components\libc\compilers\common\extension\fcntl\octal;libraries\HAL_Drivers\drivers;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\finsh;rt-thread\components\dfs\dfs_v1\filesystems\devfs;libraries\HAL_Drivers;.;rt-thread\components\libc\compilers\common\include;packages\lcd_device;rt-thread\components\drivers\phy;board;rt-thread\components\drivers\include;rt-thread\components\drivers\smp_call;rt-thread\components\drivers\touch;rt-thread\libcpu\arm\cortex-m3;applications;rt-thread\libcpu\arm\common;rt-thread\components\drivers\include;libraries\STM32F1xx_HAL\STM32F1xx_HAL_Driver\Inc;board\CubeMX_Config\Inc;rt-thread\components\dfs\dfs_v1\include;rt-thread\components\libc\posix\ipc;rt-thread\components\drivers\include;libraries\HAL_Drivers\drivers\config;rt-thread\components\libc\posix\io\poll;rt-thread\components\drivers\include;board\ports\include;rt-thread\components\libc\posix\io\eventfd;rt-thread\include;rt-thread\components\libc\posix\io\epoll;libraries\STM32F1xx_HAL\CMSIS\Device\ST\STM32F1xx\Include;rt-thread\components\libc\compilers\common\extension
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: main.c key.c key_test.c
  group Compiler
    rt-thread/components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    rt-thread/components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
  group DeviceDrivers
    rt-thread/components/drivers/core/: device.c
    rt-thread/components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    rt-thread/components/drivers/pin/: dev_pin.c
    rt-thread/components/drivers/serial/: dev_serial.c
    rt-thread/components/drivers/touch/: dev_touch.c
  group Drivers
    board/CubeMX_Config/Src/: stm32f1xx_hal_msp.c
    board/: board.c
    board/ports/: drv_sram.c
    libraries/HAL_Drivers/drivers/: drv_gpio.c drv_lcd.c drv_usart.c
    libraries/HAL_Drivers/: drv_common.c
    libraries/STM32F1xx_HAL/CMSIS/Device/ST/STM32F1xx/Source/Templates/arm/: startup_stm32f103xe.s
  group Filesystem
    rt-thread/components/dfs/dfs_v1/filesystems/devfs/: devfs.c
    rt-thread/components/dfs/dfs_v1/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
  group Finsh
    rt-thread/components/finsh/: msh.c shell.c msh_parse.c msh_file.c cmd.c
  group Kernel
    rt-thread/src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group klibc
    rt-thread/src/klibc/: kerrno.c rt_vsnprintf_tiny.c rt_vsscanf.c kstring.c kstdio.c
  group lcd_device
    packages/lcd_device/: drv_touch.c drv_lcd.c example_test.c
  group libcpu
    rt-thread/libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    rt-thread/libcpu/arm/cortex-m3/: context_rvds.S cpuport.c
  group Libraries
    libraries/STM32F1xx_HAL/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_uart.c stm32f1xx_hal_gpio.c stm32f1xx_hal_rcc.c stm32f1xx_hal_crc.c stm32f1xx_hal_cec.c stm32f1xx_ll_fsmc.c stm32f1xx_hal_pwr.c stm32f1xx_hal.c stm32f1xx_hal_dma.c stm32f1xx_hal_sram.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_cortex.c stm32f1xx_hal_usart.c stm32f1xx_hal_gpio_ex.c
    libraries/STM32F1xx_HAL/CMSIS/Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
